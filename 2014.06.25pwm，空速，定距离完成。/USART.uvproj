# Keil uVision project USART.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: USART +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\lib\inc;.\lib\src;.\sys;.\user\delay;.\user\EXTI;.\user\main;.\user\UASRT;.\user\GPIO;.\user\SD;.\user\USB-FS-Config;.\user\USB-FS-Device_Driver;.\user\FatFs;.\user\chumo;.\user\FSMC;.\user\TFT;.\user\RTC;.\user\MPU6050;.\user\CC1101;.\user\PWM;.\user\control;.\user\ultrasonic;.\user\TIMER;.\user\SPI;.\user\eeprom
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group lib
    ./lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_exti.c stm32f10x_sdio.c stm32f10x_dma.c stm32f10x_tim.c stm32f10x_fsmc.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_spi.c stm32f10x_dac.c stm32f10x_adc.c
  group sys
    ./sys/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group main
    ./user/main/: main.c stm32f10x_it.c
  group BSP
    ./user/GPIO/: GPIO.c
    ./user/delay/: delay.c
    ./user/PWM/: PWM.c PWM_comp.c
    ./user/SPI/: SPI.c
    ./user/TIMER/: TIMCap.c TIMER.c
    ./user/ADC/: ADC.c
    ./user/DAC/: DAC.c
    ./user/EXTI/: EXTI.c
    ./user/UASRT/: USART.c
    ./user/CC1101/: CC1101.c
    ./user/ultrasonic/: ultrasonic.c
    ./user/control/: Angle.c Motor.c
    ./user/eeprom/: eeprom.c
    ./user/MPU6050/: STM32_I2C.c MPU6050.c
  group SD
    ./user/SD/: sdio_sdcard.c
    ./user/FatFs/: diskio.c ff.c
  group TFT
    ./user/TFT/: lcd_dis24.c zhu.c BMP.c TFT_M.c TFT_Show.c Slider.c button.c Window.c WindowP.c
    ./user/FSMC/: FSMC_TFT.c
    ./user/chumo/: XPT2046.c
  group USB
    ./user/USB-FS-Device_Driver/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USBcf
    ./user/USB-FS-Config/: hw_config.c mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
