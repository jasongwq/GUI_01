# Keil uVision project main.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\lib;.\sys;.\user;.\user\exti;.\user\tim;.\user\adc;.\user\pwm;.\user\spi&iic;.\user\mpu6050;.\user\kalman;.\user\dac;.\user\screen;.\user\ov7670;.\user\sdcard;.\user\bmp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group lib
    ./lib/: STM32_lib_3.0.lib
  group sys
    ./sys/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group user
    ./user/: main.c stm32f10x_it.c stm32f10x_conf.h gpio.c usart.c delay.c
